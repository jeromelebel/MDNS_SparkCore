// This #include statement was automatically added by the Spark IDE.
#include "sparkMDNS_jeromelebel.h"

#define LISTEN_PORT 7

TCPServer echoServer(LISTEN_PORT);
MDNSResponder mdns;

char szIP[64];
bool isStarted;
char szHTML[] = "<html><body><p>Spark Core and MDNS Working :)</p></body></html>";

TCPServer server = TCPServer(80);

void setup() {
    // Begin MDNS
    isStarted = mdns.begin("myspark");
    
    // If started, set the variable to IP address of the Spark Core
    // else set error message
    if(isStarted) {
		sprintf(szIP, "MDNS started");
        server.begin();
    }
    else{
        sprintf(szIP, "Error starting MDNS.");
    }
    
    Spark.variable("mdnsstatus", szIP, STRING);
}

void loop() {
    // If we started successfully, then wait for the client to connect
    // else do nothing
    if(isStarted){
        mdns.update();
        
        TCPClient client = server.available();
        if (client){
            client.write(szHTML);
            client.flush();
            client.stop();
        }
    }
    
    delay(2000);
}